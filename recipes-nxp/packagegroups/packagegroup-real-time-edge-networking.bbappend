RDEPENDS:${PN}:remove = "ebtables"

