SRCBRANCH = "ros2"
#SRC_URI = "git://github.com/moveit/moveit_task_constructor.git;protocol=https;branch=${SRCBRANCH};subpath=msgs"

